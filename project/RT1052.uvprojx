# Keil uVision project RT1052.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1052 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: QSPI_BOOT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0,FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\libraries\board;..\libraries\board\sdmmc_port;..\libraries\drivers;..\libraries\startup;..\libraries\startup\Include;..\libraries\utilities;..\libraries\utilities\io;..\libraries\utilities\log;..\libraries\utilities\str;..\libraries\xip;..\rtos;..\rtos\amazon-freertos\lib\FreeRTOS\portable\RVDS\ARM_CM4F;..\rtos\amazon-freertos\lib\include;..\rtos\amazon-freertos\lib\include\private;..\rtos\template_application\ARM_CM4F;..\sdmmc\src;..\sdmmc\inc;..\sdmmc\port;..\fatfs\src;..\fatfs\src\option;..\fatfs\src\fsl_sd_disk;..\emwin\emWin_Config;..\emwin\emWin_header;..\emwin\template_application;..\emwin\Keyboard;..\malloc;..\GUI;..\STemWinHZ
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\libraries\startup\arm\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt)
  group user
    ../user/: mian.c
    ../libraries/board/: include.h
    ../rtos/template_application/ARM_CM4F/: FreeRTOSConfig.h
    ../libraries/board/sdmmc_port/: ffconf.h
    ./: 开发日志.txt
  group board
    ../libraries/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h led.c led.h sdram.c sdram.h uart2.c uart2.h i2c.c i2c.h bq25895.c bq25895.h eeprom.c eeprom.h touch.c touch.h ILI9806.c ILI9806.h elcdif.c elcdif.h TF.c TF.h nrf24l01.c nrf24l01.h svns_rtc.c svns_rtc.h wm8960.c wm8960.h sai.c sai.h
  group malloc
    ../malloc/: malloc.c
  group drivers
    ../libraries/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_lpuart.c fsl_gpio.c fsl_elcdif.c fsl_semc.c fsl_lpi2c.c fsl_usdhc.c fsl_trng.c fsl_sai.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_pwm.c fsl_pwm.h fsl_xbara.c fsl_xbara.h
  group startup
    ../libraries/startup/: system_MIMXRT1052.c system_MIMXRT1052.h
    ../libraries/startup/arm/: startup_MIMXRT1052.s
  group utilities
    ../libraries/utilities/io/: fsl_io.c
    ../libraries/utilities/log/: fsl_log.c
    ../libraries/utilities/str/: fsl_str.c
    ../libraries/utilities/: fsl_debug_console.c fsl_assert.c
  group xip
    ../libraries/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_flash.c
  group freertos-FreeRTOS
    ../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos-FreeRTOS-portable
    ../rtos/amazon-freertos/lib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portmacro.h
    ../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../rtos/: cpu_utils.c
  group fatfs-fatfs_source
    ../fatfs/src/fsl_sd_disk/: fsl_sd_disk.c
    ../fatfs/src/: ff.c diskio.c
  group sdmmc-src
    ../sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group sdmmc-port
    ../libraries/board/sdmmc_port/: fsl_sdmmc_host.c fsl_sdmmc_event.c fsl_sdmmc_event.h
  group emwin-emWin_header
    ../emwin/emWin_header/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D15G00.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group emwin-emWin_Config
    ../emwin/template_application/: emwin_support.c
    ../emwin/emWin_Config/: GUIConf.c GUIConf.h LCDConf.h
  group emwin-emWin_lib
    ../emwin/emWin_library/Keil/: emWin_M4F.lib
  group emwin-DEOM
    ../GUI/: MainTask.c MainTask.h App_StatusDlg.c App_SysInfoDlg.c APP_FileDlg.c APP_Calendar.c APP_CalendarSet.c APP_WifiDlg.c APP_ComputerDlg.c APP_BatteryDlg.c App_Wireless.c APP_WirelessSet.c APP_PMUDlg.c APP_JoyDlg.c
  group emwin-picture
    ../emwin/Picture/: ClockBkPic.c DestWin.c
  group emwin-keypad
    ../emwin/Keyboard/: pymb.c WindowSKB.c
  group GUI-HZ
    ../STemWinHZ/: GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c Hzfontupdata.c
